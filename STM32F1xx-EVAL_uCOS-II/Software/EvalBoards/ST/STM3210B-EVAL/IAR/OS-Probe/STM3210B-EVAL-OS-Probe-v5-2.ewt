<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Flash</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <group>
      <name>General</name>
      <file>
        <name>$PROJ_DIR$\app.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\app_vect_v5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\includes.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\os_cfg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\probe_com_cfg.h</name>
      </file>
    </group>
    <group>
      <name>ST</name>
      <file>
        <name>$PROJ_DIR$\stm32f10x_conf.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>General</name>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_int.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\bsp_periph.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\STM32_Flash.icf</name>
      </file>
    </group>
    <group>
      <name>LCD</name>
      <file>
        <name>$PROJ_DIR$\..\BSP\fonts.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\lcd.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\BSP\lcd.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>FWLib</name>
    <group>
      <name>inc</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\cortexm3_macro.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_adc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_bkp.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_can.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_dma.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_exti.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_flash.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_gpio.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_i2c.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_iwdg.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_lib.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_map.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_nvic.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_pwr.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_rcc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_rtc.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_spi.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_systick.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_tim.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_type.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_usart.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\inc\stm32f10x_wwdg.h</name>
      </file>
    </group>
    <group>
      <name>src</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_lib.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_nvic.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_systick.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\CPU\ST\STM32\src\stm32f10x_wwdg.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>uC/CPU</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR\cpu.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR\cpu_a.asm</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\ARM-Cortex-M3\IAR\cpu_c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-CPU\cpu_def.h</name>
    </file>
  </group>
  <group>
    <name>uC/LIB</name>
    <group>
      <name>Ports</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\Ports\ARM-Cortex-M3\IAR\lib_mem_a.asm</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_def.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_mem.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_str.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\..\..\uC-LIB\lib_str.h</name>
    </file>
  </group>
  <group>
    <name>uC/OS-II</name>
    <group>
      <name>Port</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_a.asm</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_cpu_c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\os_dbg.c</name>
      </file>
    </group>
    <group>
      <name>Source</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_core.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_flag.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mbox.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_mutex.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_q.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_sem.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_task.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_time.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\os_tmr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\..\..\uCOS-II\Source\ucos_ii.h</name>
      </file>
    </group>
  </group>
  <group>
    <name>uC/Probe</name>
    <group>
      <name>Target</name>
      <group>
        <name>Communication</name>
        <group>
          <name>OS</name>
          <group>
            <name>uCOS-II</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\OS\uCOS-II\probe_com_os.c</name>
            </file>
          </group>
        </group>
        <group>
          <name>RS-232</name>
          <group>
            <name>OS</name>
            <group>
              <name>uCOS-II</name>
              <file>
                <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\OS\uCOS-II\probe_rs232_os.c</name>
              </file>
            </group>
          </group>
          <group>
            <name>Ports</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32\probe_rs232c.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Ports\ST\STM32\probe_rs232c.h</name>
            </file>
          </group>
          <group>
            <name>Source</name>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Source\probe_rs232.c</name>
            </file>
            <file>
              <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\RS-232\Source\probe_rs232.h</name>
            </file>
          </group>
        </group>
        <group>
          <name>Source</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\Source\probe_com.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Communication\Generic\Source\probe_com.h</name>
          </file>
        </group>
      </group>
      <group>
        <name>Plugins</name>
        <group>
          <name>uCOS-II</name>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Plugins\uCOS-II\os_probe.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\..\..\..\..\..\uC-Probe\Target\Plugins\uCOS-II\os_probe.h</name>
          </file>
        </group>
      </group>
    </group>
  </group>
</project>


